# Repository jonolt/KiCad-Scripted-StudioClock

File README.md:

# KiCad - Studio Clock

## Python Scripting Example: Studio Clock

This project shows how to fully script and parametrize the creation of a analog studio clock with LED minute and hour points and 7 Segment digits in the center.

This is the revival of the code i posted in a quite popular post in the KiCad forums:

https://forum.kicad.info/t/python-scripting-example-studio-clock/5387

Since the original code was rather anti-pythonic and difficult to read and understand, I first ported it to Python 3 and reformatted it with the black formatter to improve it step by step. The result is a completely new code that shares only the logic with the original. The originally uploaded Python2 code can be found in the first commit of this repository.

Note: StudioClock-rescue.lib is needed for the old 7 Segment Symbol.

## KiCad design StudioClock.kicad_pcb

File README.rst:

KiCad - Studio Clock
####################

Python Scripting Example: Studio Clock
======================================

This project shows how to fully script and parametrize the creation of a analog studio clock with LED minute and hour points and 7 Segment digits in the center.

This is the revival of the code i posted in a quite popular post in the KiCad forums:

https://forum.kicad.info/t/python-scripting-example-studio-clock/5387

Since the original code was rather anti-pythonic and difficult to read and understand, I first ported it to Python 3 and reformatted it with the black formatter to improve it step by step. The result is a completely new code that shares only the logic with the original. The originally uploaded Python2 code can be found in the first commit of this repository.

Note: StudioClock-rescue.lib is needed for the old 7 Segment Symbol.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74: LED; LED_0805_2012Metric
J1, J2: CONN_01X16; PinHeader_1x16_P2.54mm_Vertical_SMD_Pin1Left
U1, U2, U3, U4: 7SEGMENTS; 7SEGMENT-LED__HDSM531_HDSM533_SMD

Connections:
/a0: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), J2.12
/a1: D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A), J2.10
/a2: D31.2 (A), D32.2 (A), D33.2 (A), D34.2 (A), D35.2 (A), D36.2 (A), D37.2 (A), D38.2 (A), D39.2 (A), D40.2 (A), D41.2 (A), D42.2 (A), D43.2 (A), D44.2 (A), D45.2 (A), J2.7
/a3: D46.2 (A), D47.2 (A), D48.2 (A), D49.2 (A), D50.2 (A), D51.2 (A), D52.2 (A), D53.2 (A), D54.2 (A), D55.2 (A), D56.2 (A), D57.2 (A), D58.2 (A), D59.2 (A), D60.2 (A), J2.5
/a4: D61.2 (A), D62.2 (A), D63.2 (A), D64.2 (A), D65.2 (A), D66.2 (A), D67.2 (A), D68.2 (A), D69.2 (A), D70.2 (A), D71.2 (A), D72.2 (A), J2.3, J2.14
/a11: D73.2 (A), J2.9
/a21: D74.2 (A), J2.8
/a50: J2.1, U1.3 (C.A.), U1.8 (C.A.)
/a51: J2.11, U3.3 (C.A.), U3.8 (C.A.)
/a60: J2.6, U2.3 (C.A.), U2.8 (C.A.)
/a61: J2.16, U4.3 (C.A.), U4.8 (C.A.)
/k0: D1.1 (K), D30.1 (K), D31.1 (K), D60.1 (K), D71.1 (K), J1.1, U1.6 (b), U2.6 (b)
/k1: D2.1 (K), D29.1 (K), D32.1 (K), D59.1 (K), J1.2, U1.5 (DP), U2.5 (DP)
/k2: D3.1 (K), D28.1 (K), D33.1 (K), D58.1 (K), D66.1 (K), J1.3, U1.7 (a), U2.7 (a)
/k3: D4.1 (K), D27.1 (K), D34.1 (K), D57.1 (K), D67.1 (K), J1.4, U1.4 (c), U2.4 (c)
/k4: D5.1 (K), D26.1 (K), D35.1 (K), D56.1 (K), J1.5, U1.9 (f), U2.9 (f)
/k5: D6.1 (K), D25.1 (K), D36.1 (K), D55.1 (K), D72.1 (K), J1.6, U1.2 (d), U2.2 (d)
/k6: D7.1 (K), D24.1 (K), D37.1 (K), D54.1 (K), D62.1 (K), J1.7, U1.10 (g), U2.10 (g)
/k7: D8.1 (K), D23.1 (K), D38.1 (K), D53.1 (K), D65.1 (K), J1.8, U1.1 (e), U2.1 (e)
/k8: D9.1 (K), D22.1 (K), D39.1 (K), D52.1 (K), D68.1 (K), J1.9, U3.10 (g), U4.10 (g)
/k9: D10.1 (K), D21.1 (K), D40.1 (K), D51.1 (K), D69.1 (K), J1.10, U3.9 (f), U4.9 (f)
/k10: D11.1 (K), D20.1 (K), D41.1 (K), D50.1 (K), D61.1 (K), J1.11, U3.2 (d), U4.2 (d)
/k11: D12.1 (K), D19.1 (K), D42.1 (K), D49.1 (K), D63.1 (K), J1.12, U3.7 (a), U4.7 (a)
/k12: D13.1 (K), D18.1 (K), D43.1 (K), D48.1 (K), D64.1 (K), J1.13, U3.4 (c), U4.4 (c)
/k13: D14.1 (K), D17.1 (K), D44.1 (K), D47.1 (K), J1.14, U3.6 (b), U4.6 (b)
/k14: D15.1 (K), D16.1 (K), D45.1 (K), D46.1 (K), D70.1 (K), J1.15, U3.5 (DP), U4.5 (DP)
/k15: D73.1 (K), D74.1 (K), J1.16, U3.1 (e), U4.1 (e)

Board: 2 copper layers, 100.0 x 100.0 mm, 80 parts (2 on the bottom side), 27 nets.

## Commit log

2020-07-21 initial commit ...
    ... with files as i found them on my disk
2022-07-13 replaced print, black formatted
2022-07-31 script runs, updated symbols and footprints
2022-07-31 cleanup, pep8
2022-07-31 restructured code, some tracks missing
    generating code of missing was commented out
2022-07-31 fixed all errors, made code more pythonic
2022-07-31 docstrings and cleanup comments
2022-07-31 executed and cleaned up files, added README
2022-08-05 Create CC0 License from GitHub template
